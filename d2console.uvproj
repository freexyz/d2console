# Keil uVision project d2console.uvproj, settings and files
target d2console (MCS-51)
  device: M8051W Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MODP2
  output: d2console +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group common
    ./common/: command.c terminal.c cmd_mem.c xmodem.c cmd_lpbk.c cmd_align.c cmd_stitch.c cmd_side.c cmd_i2c.c cmd_csp.c
  group doc
    ./doc/: ReadMe.txt xmodem.txt xmodem1K.txt xmodemCRC.txt xmodemORG.txt
  group drivers
    ./drivers/serial/: serial.c
    ./drivers/d2/: siu.c ipu.c sou.c align.c pio.c
    ./drivers/i2c/: i2c_gpio.c
    ./drivers/tvdec/: t515bm.c
  group dvt
    ./dvt/: dvt_mem.c dvt_loopback.c dvt_accurate.c dvt_align.c dvt_fussy.c dvt_hside.c dvt_vside.c dvt_csp.c
  group init
    ./init/: main.c d2startup.a51 init.c
  group lib
    ./lib/: getkey.c putchar.c delay.c misc.c memory.c
